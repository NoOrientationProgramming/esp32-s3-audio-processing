## main/Kconfig
```kconfig
menu "Application Main"

config CMD_SIZE_BUFFER_OUT
	int "Command output buffer size"
	default "2000"
	help
		Maximum size for command output messages

endmenu
```
